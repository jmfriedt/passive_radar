options:
  parameters:
    generate_options: qt_gui
    id: dual_rtl_sdr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f
  id: variable_qtgui_range
  parameters:
    comment: Tune to the DVB-T emitter frequency
    start: '400'
    step: '.1'
    stop: '800'
    value: '500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/output.bin
    type: complex
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: f*1e6
    gain0: '39'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: f*1e6
    gain0: '39'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_interleave_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_interleave_0, '0']
- [osmosdr_source_0_0, '0', blocks_interleave_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
